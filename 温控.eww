<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x6e29;&#x63A7;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


